Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2019-05-31T14:22:35
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri May 31 14:22:35 2019 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{C67230B0-7B59-48DD-90B2-2255D72E9BCD}\ifc * Database version: 5507 * Database creation date: Fri May 31 14:22:34 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri May 31 14:22:35 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri May 31 14:22:35 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: P:\Fastrack\53721_DOLPHIN SOLUTIONS LIMITED\ADDITIONAL DRAWINGS 2019 BIM\05$MAY\06-0160.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Weight: 1; Line Pattern: -3000010; Symbol at End 2 Default: yes; Color: 0; Symbol at End 1 Default: no

# IfcBuildingElementProxy: 06.0160 Dolphin Automatic Foam Soap Dispenser - Behind Mirror, 06-0160:06.0160 Dolphin Automatic Foam Soap Dispenser - Behind Mirror:23845
In: Level 1
Material: Plastic, Stainless Steel, Lid, Glass
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1; Offset: 0 mm
Dimensions - Volume: 0.00274285 m3; Recommended Minimum Distance: 300mm Min Height to Counter Top.; Height: 400mm; Projection: 135mm; Width: 108mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Dolphin Solutions Ltd.
Pset_BuildingElementProxyCommon - Reference: 06.0160 Dolphin Automatic Foam Soap Dispenser - Behind Mirror
Identity Data - Email: info@dolphinsolutions.co.uk; Model: 06.0160; Tel No.: +44 (0) 1424 202224; URL: www.dolphinsolutions.co.uk; Description: Behind mirror automatic soap dispenser; Fax No.: +44 (0) 1424 205200; Manufacturer: Dolphin Solutions Ltd.; Assembly Description: Misc. Other Plumbing Systems; Address: Southpoint, Compass Park, Junction Road, Bodiam, TN32 5BS; Assembly Code: D2090900
General - Warranty: 12 months from date of purchase.; Product Data: Behind mirror, drop down, automatic foam soap dispenser - stainless steel. Usage: Medium Traffic Areas.; Product Page Link: https://www.dolphinsolutions.co.uk/en/product/dolphin-automatic-foam-soap-dispenser-behind-mirror/
Materials and Finishes - Finish: Brushed Satin Stainless Steel
Other - Usage: Medium Traffic Areas.
Electrical - Power options: Powered by 4xAA (1.5V) Alkaline batteries, 6V DC. Fitted with low battery indicator.
